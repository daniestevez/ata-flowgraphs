options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: usrp_record_iq
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Record IQ data from the two USRPs
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: uhd.tune_request(512e6, samp_rate)
  states: {}
- name: metadata
  id: variable
  parameters:
    value: pmt.dict_add(pmt.dict_add(pmt.dict_add(pmt.make_dict(), pmt.intern('source'), pmt.intern(src_name)), pmt.intern('lo_freq'), pmt.from_double(lo_freq)), pmt.intern('antennas'), pmt.intern(antennas))
  states: {}
- name: antennas
  id: parameter
  parameters:
    type: str
    value: '''unknown'''
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0x'
    max_seg_size: int(samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0y'
    max_seg_size: int(samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_1x'
    max_seg_size: int(samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_0_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_1y'
    max_seg_size: int(samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: directory
  id: parameter
  parameters:
    type: str
    value: '"/mnt/buf0"'
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '40'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    type: eng_float
    value: '-1.0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 30.72e6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_source_0.set_time_next_pps(uhd.time_spec(int(time.time())+1))
      self.uhd_usrp_source_0.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source_0.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source_0.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 1)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 2)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 3)
      time.sleep(1)
    section: main_after_init
  states: {}
- name: src_name
  id: parameter
  parameters:
    type: str
    value: '''unknown_source'''
  states: {}
- name: timestamp
  id: parameter
  parameters:
    type: str
    value: datetime.utcnow().isoformat()
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_rate: '0.0'
    dev_addr: '"addr0=10.11.1.20,addr1=10.11.1.22,clock_source=external,time_source=external"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    nchan: '4'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_meta_sink_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_meta_sink_0_0, '0']
- [uhd_usrp_source_0, '2', blocks_file_meta_sink_0_0_0, '0']
- [uhd_usrp_source_0, '3', blocks_file_meta_sink_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
