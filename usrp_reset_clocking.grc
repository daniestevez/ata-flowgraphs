options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: usrp_reset_clocking
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Set the USRP to 250 MHz MCR to reset problems caused by clocking
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 512e6
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: '0'
    type: complex
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: '0'
    type: complex
  states: {}
- name: blocks_head_0_0_1
  id: blocks_head
  parameters:
    num_items: '0'
    type: complex
  states: {}
- name: blocks_head_0_0_2
  id: blocks_head
  parameters:
    num_items: '0'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 25e6
  states: {}
- name: snippet_2
  id: snippet
  parameters:
    code: |-
      print('>>> Setting LO sharing')
      self.uhd_usrp_source_0.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source_0.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source_0.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 1)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 2)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 3)
    section: main_after_init
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_rate: '0.0'
    dev_addr: '"addr0=10.11.1.20, addr1=10.11.1.22, clock_source=external, time_source=external, ref_clk_freq=10e6, master_clock_rate=250e6"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    nchan: '4'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0_0, '0', blocks_null_sink_0, '0']
- [blocks_head_0_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_head_0_0_1, '0', blocks_null_sink_0_1, '0']
- [blocks_head_0_0_2, '0', blocks_null_sink_0_2, '0']
- [uhd_usrp_source_0, '0', blocks_head_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_head_0_0_0, '0']
- [uhd_usrp_source_0, '2', blocks_head_0_0_1, '0']
- [uhd_usrp_source_0, '3', blocks_head_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
