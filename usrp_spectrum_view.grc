options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: usrp_spectrum_view
    output_language: python
    run_options: run
    title: View spectrum from the two USRPs
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: uhd.tune_request(512e6, samp_rate)
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: t_int
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: round(t_int*samp_rate/nfft)
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: round(t_int*samp_rate/nfft)
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: round(t_int*samp_rate/nfft)
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: round(t_int*samp_rate/nfft)
    type: float
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '40'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '4'
    vlen: nfft
    x_axis_label: '"Frequency (MHz)"'
    x_start: '-samp_rate/2*1e-6'
    x_step: samp_rate/nfft*1e-6
    x_units: '"MHz"'
    y_axis_label: '"PSD (dB)"'
    y_units: '"dB"'
    ymax: '50'
    ymin: '10'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 40.96e6
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_source.set_time_next_pps(uhd.time_spec(int(time.time())+1))
      self.uhd_usrp_source.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 1)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 2)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 3)
      time.sleep(1)
    section: main_after_init
  states: {}
- name: src_name
  id: parameter
  parameters:
    type: str
    value: '''unknown_source'''
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    dev_addr: '"addr0=10.11.1.20,addr1=10.11.1.22,clock_source=external,time_source=external"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    nchan: '4'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_1, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_integrate_xx_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_nlog10_ff_0_2, '0']
- [blocks_integrate_xx_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_nlog10_ff_0_1, '0', qtgui_vector_sink_f_0, '2']
- [blocks_nlog10_ff_0_2, '0', qtgui_vector_sink_f_0, '3']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_2, '0', fft_vxx_0_2, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_0_0_1, '0']
- [fft_vxx_0_2, '0', blocks_complex_to_mag_squared_0_2, '0']
- [uhd_usrp_source, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source, '1', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source, '2', blocks_stream_to_vector_0_2, '0']
- [uhd_usrp_source, '3', blocks_stream_to_vector_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
